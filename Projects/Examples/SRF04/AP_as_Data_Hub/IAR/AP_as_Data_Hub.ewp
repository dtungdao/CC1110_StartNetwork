# IAR project AP_as_Data_Hub.ewp, settings and files
configuration CC1110-End Device (8051, debug)
  General.OGChipSelectMenu: CC1110F32 CC1110F32
  ICC8051.CCDefines: MCU_H=<ioCC1110.h>; MRFI_CC1110
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\..\..\..\..\Components\bsp; ..\..\..\..\..\Components\bsp\drivers; ..\..\..\..\..\Components\bsp\boards\SRF04EB; ..\..\..\..\..\Components\mrfi; ..\..\..\..\..\Components\SimpliciTI\nwk; ..\..\..\..\..\Components\SimpliciTI\nwk_applications; C:\Texas Instruments\SimpliciTI-IAR-1.2.0\components - Copy\common; C:\Texas Instruments\SimpliciTI-IAR-1.2.0\components - Copy\radio\ccxx10; C:\Texas Instruments\SimpliciTI-IAR-1.2.0\components - Copy\common\cc8051
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_CC1110F32.xcl
configuration CC1110-Access Point (8051, debug)
  as the first configuration, except:
configuration CC1110-Channel Sniffer (8051, debug)
  as the first configuration, except:
  General.OGChipSelectMenu: 8052 Generic 8052
  ICC8051.CCDefines: MCU_H=<ioCC1110.h>; MRFI_CC1110; NUM_CONNECTIONS=0
  ICC8051.CCIncludePath2: ..\..\..\..\..\Components\bsp; ..\..\..\..\..\Components\bsp\drivers; ..\..\..\..\..\Components\bsp\boards\SRF04EB; ..\..\..\..\..\Components\mrfi; ..\..\..\..\..\Components\SimpliciTI\nwk; ..\..\..\..\..\Components\SimpliciTI\nwk_applications
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnk51ew_cc1110.xcl
configuration CC1110-Range Extender (8051, debug)
  as the first configuration, except:
  General.OGChipSelectMenu: 8052 Generic 8052
  ICC8051.CCIncludePath2: as above
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnk51ew_cc1110.xcl
configuration CC2430-End Device (8051, debug)
  as the first configuration, except:
  General.OGChipSelectMenu: CC2430F128 CC2430F128
  ICC8051.CCDefines: MCU_H=<ioCC2430.h>; MRFI_CC2430; xMCU_H=<ioCC2431.h>; xMRFI_CC2431
  ICC8051.CCIncludePath2: as above
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_CC2430F128.xcl
configuration CC2430-Access Point (8051, debug)
  as the first configuration, except:
  General.OGChipSelectMenu: CC2430F128 CC2430F128
  ICC8051.CCDefines: as above
  ICC8051.CCIncludePath2: as above
  XLINK.XclFile: as above
configuration CC2430-Channel Sniffer (8051, debug)
  as the first configuration, except:
  General.OGChipSelectMenu: CC2430F128 CC2430F128
  ICC8051.CCDefines: MCU_H=<ioCC2430.h>; MRFI_CC2430; xMCU_H=<ioCC2431.h>; xMRFI_CC2431; NUM_CONNECTIONS=0
  ICC8051.CCIncludePath2: as above
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Chipcon\lnk51ew_CC2430.xcl
configuration CC2430-Range Extender (8051, debug)
  as the first configuration, except:
  General.OGChipSelectMenu: CC2430F128 CC2430F128
  ICC8051.CCDefines: as above
  ICC8051.CCIncludePath2: as above
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_CC2431F128.xcl
configuration CC2510-End Device (8051, debug)
  as the first configuration, except:
  General.OGChipSelectMenu: 8052 Generic 8052
  ICC8051.CCDefines: MCU_H=<ioCC2510.h>; MRFI_CC2510
  ICC8051.CCIncludePath2: as above
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnk51ew_cc2510.xcl
configuration CC2510-Access Point (8051, debug)
  as the first configuration, except:
  General.OGChipSelectMenu: 8052 Generic 8052
  ICC8051.CCDefines: MCU_H=<ioCC2510.h>; MRFI_CC2510
  ICC8051.CCIncludePath2: as above
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnk51ew_cc2510.xcl
configuration CC2510-Channel Sniffer (8051, debug)
  as the first configuration, except:
  General.OGChipSelectMenu: 8052 Generic 8052
  ICC8051.CCDefines: MCU_H=<ioCC2510.h>; MRFI_CC2510; NUM_CONNECTIONS=0
  ICC8051.CCIncludePath2: as above
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnk51ew_cc2510.xcl
configuration CC2510-Range Extender (8051, debug)
  as the first configuration, except:
  General.OGChipSelectMenu: 8052 Generic 8052
  ICC8051.CCDefines: MCU_H=<ioCC2510.h>; MRFI_CC2510
  ICC8051.CCIncludePath2: as above
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnk51ew_cc2510.xcl
  group Components/bsp
    ../../../../../Components/bsp/: bsp.c bsp.h bsp_macros.h
  group Components/mrfi
    ../../../../../Components/mrfi/: mrfi.c mrfi.h mrfi_defs.h
  group Components/nwk
    ../../../../../Components/simpliciti/nwk/: nwk.c nwk.h nwk_api.c nwk_api.h nwk_app.h nwk_frame.c nwk_frame.h nwk_globals.c nwk_globals.h nwk_QMgmt.c nwk_QMgmt.h nwk_types.h
  group Components/nwk applications
    ../../../../../Components/simpliciti/nwk_applications/: nwk_freq.c nwk_ioctl.c nwk_join.c nwk_link.c nwk_mgmt.c nwk_ping.c nwk_pll.c nwk_security.c
    ../../../../../Components/SimpliciTI/nwk_applications/: nwk_freq.h nwk_ioctl.h nwk_join.h nwk_link.h nwk_mgmt.h nwk_ping.h nwk_pll.h nwk_security.h
  group peer applications/application
    ../../../Applications/: debugging.c debugging.h
  group peer applications/application/Access Point
    ../../../Applications/: main_AP_Async_Listen.c main_AP_Async_Listen_autoack.c
  group peer applications/application/Channel Sniffer
    ../../../Applications/: main_ED_Sniffer.c
  group peer applications/application/End Device
    ../../../Applications/: main_manyEDs.c main_manyEDs_autoack.c
  group peer applications/application/Range Extender
    ../../../Applications/: main_AP_RE.c
  group peer applications/Configuration
    Configuration/: smpl_nwk_config.dat
  group peer applications/Configuration/Access Point
    Configuration/Access_Point/: smpl_config.dat
  group peer applications/Configuration/End Device
    Configuration/End_Device/: smpl_config.dat
  group peer applications/Configuration/Range Extender
    Configuration/Range_Extender/: smpl_config.dat
