# IAR project Simple_Peer_To_Peer.ewp, settings and files
configuration CC1110-LinkTo (8051, debug)
  General.OGChipSelectMenu: CC1110F16 CC1110F16
  ICC8051.CCDefines: MCU_H=<ioCC1110.h>; MRFI_CC1110; SOC_BB
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\..\..\..\..\Components\bsp; ..\..\..\..\..\Components\bsp\drivers; ..\..\..\..\..\Components\bsp\boards\SRF04EB; ..\..\..\..\..\Components\mrfi; ..\..\..\..\..\Components\SimpliciTI\nwk; ..\..\..\..\..\Components\SimpliciTI\nwk_applications; C:\Texas Instruments\SimpliciTI-IAR-1.2.0\components - Copy\common; C:\Texas Instruments\SimpliciTI-IAR-1.2.0\components - Copy\radio\ccxx10; C:\Texas Instruments\SimpliciTI-IAR-1.2.0\components - Copy\common\cc8051
  ICC8051.CCOptLevel: 0
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_CC1110F16.xcl
configuration CC1110-LinkListen (8051, debug)
  as the first configuration, except:
  General.OGChipSelectMenu: CC1110F32 CC1110F32
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_CC1110F32.xcl
configuration CC2430-LinkTo (8051, debug)
  as the first configuration, except:
  General.OGChipSelectMenu: CC2430F128 CC2430F128
  ICC8051.CCDefines: MCU_H=<ioCC2430.h>; MRFI_CC2430; xMCU_H=<ioCC2431.h>; xMRFI_CC2431
  ICC8051.CCIncludePath2: ..\..\..\..\..\Components\bsp; ..\..\..\..\..\Components\bsp\drivers; ..\..\..\..\..\Components\bsp\boards\SRF04EB; ..\..\..\..\..\Components\mrfi; ..\..\..\..\..\Components\SimpliciTI\nwk; ..\..\..\..\..\Components\SimpliciTI\nwk_applications
  ICC8051.CCOptLevel: 3
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_CC2430F128.xcl
configuration CC2430-LinkListen (8051, debug)
  as the first configuration, except:
  General.OGChipSelectMenu: CC2430F128 CC2430F128
  ICC8051.CCDefines: as above
  ICC8051.CCIncludePath2: as above
  ICC8051.CCOptLevel: 3
  XLINK.XclFile: as above
configuration CC2510-LinkTo (8051, debug)
  as the first configuration, except:
  General.OGChipSelectMenu: 8052 Generic 8052
  ICC8051.CCDefines: MCU_H=<ioCC2510.h>; MRFI_CC2510
  ICC8051.CCIncludePath2: as above
  ICC8051.CCOptLevel: 3
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnk51ew_cc2510.xcl
configuration CC2510-LinkListen (8051, debug)
  as the first configuration, except:
  General.OGChipSelectMenu: 8052 Generic 8052
  ICC8051.CCDefines: MCU_H=<ioCC2510.h>; MRFI_CC2510
  ICC8051.CCIncludePath2: as above
  ICC8051.CCOptLevel: 3
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnk51ew_cc2510.xcl
  group Components/bsp
    ../../../../../Components/bsp/: bsp.c bsp.h bsp_macros.h
  group Components/mrfi
    ../../../../../Components/mrfi/: mrfi.c mrfi.h mrfi_defs.h
  group Components/nwk
    ../../../../../Components/simpliciti/nwk/: nwk.c nwk.h nwk_api.c nwk_api.h nwk_app.h nwk_frame.c nwk_frame.h nwk_globals.c nwk_globals.h nwk_QMgmt.c nwk_QMgmt.h nwk_types.h
  group Components/nwk applications
    ../../../../../Components/simpliciti/nwk_applications/: nwk_freq.c nwk_freq.h nwk_ioctl.c nwk_ioctl.h nwk_join.c nwk_join.h nwk_link.c nwk_link.h nwk_mgmt.c nwk_mgmt.h nwk_ping.c nwk_ping.h nwk_pll.c nwk_pll.h nwk_security.c nwk_security.h
  group peer applications/application
    ../../../Applications/: debugging.c debugging.h
  group peer applications/application/LinkListen
    ../../../Applications/: main_LinkListen.c
  group peer applications/application/LinkTo
    ../../../Applications/: main_LinkTo.c
  group peer applications/Configuration
    Configuration/: smpl_nwk_config.dat
  group peer applications/Configuration/End Device
    Configuration/End_Device/: smpl_config.dat
