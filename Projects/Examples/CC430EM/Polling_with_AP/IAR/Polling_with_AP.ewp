# IAR project Polling_with_AP.ewp, settings and files
configuration CC430F5137-AccessPoint (MSP430, debug)
  General.OGChipSelectMenu: CC430F5137 CC430F5137
  General.GStackSize2: 300
  General.GHeapSize2: 0
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: MRFI_CC430
  ICC430.IExtraOptions: -f"Configuration\Access_Point\smpl_config.dat"; -f"Configuration\smpl_nwk_config.dat"
  ICC430.newCCIncludePaths: ..\..\..\..\..\Components\bsp; ..\..\..\..\..\Components\bsp\drivers; ..\..\..\..\..\Components\bsp\boards\CC430EM; ..\..\..\..\..\Components\mrfi; ..\..\..\..\..\Components\SimpliciTI\nwk; ..\..\..\..\..\Components\SimpliciTI\nwk_applications
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnkCC430F5137.xcl
  XLINK.XlinkStackSize: 1
configuration CC430F5137-RangeExtender (MSP430, debug)
  as the first configuration, except:
  ICC430.IExtraOptions: -f"Configuration\Range_Extender\smpl_config.dat"; -f"Configuration\smpl_nwk_config.dat"
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnkCC430F6137.xcl
configuration CC430F5137-Receiver (MSP430, debug)
  as the first configuration, except:
  ICC430.CCDefines: MRFI_CC430; RX_POLLS
  ICC430.IExtraOptions: -f"Configuration\End_Device\smpl_config.dat"; -f"Configuration\smpl_nwk_config.dat"
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnkCC430F6137.xcl
configuration CC430F5137-Sender (MSP430, debug)
  as the first configuration, except:
  ICC430.IExtraOptions: as above
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnkCC430F6137.xcl
configuration CC430F6137-AccessPoint (MSP430, debug)
  as the first configuration, except:
  General.OGChipSelectMenu: CC430F6137 CC430F6137
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnkCC430F6137.xcl
configuration CC430F6137-RangeExtender (MSP430, debug)
  as the first configuration, except:
  General.OGChipSelectMenu: CC430F6137 CC430F6137
  ICC430.IExtraOptions: as above
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnkCC430F6137.xcl
configuration CC430F6137-Receiver (MSP430, debug)
  as the first configuration, except:
  General.OGChipSelectMenu: CC430F6137 CC430F6137
  ICC430.CCDefines: MRFI_CC430; RX_POLLS
  ICC430.IExtraOptions: as above
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnkCC430F6137.xcl
configuration CC430F6137-Sender (MSP430, debug)
  as the first configuration, except:
  General.OGChipSelectMenu: CC430F6137 CC430F6137
  ICC430.IExtraOptions: as above
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnkCC430F6137.xcl
  group Components/bsp
    ../../../../../Components/bsp/: bsp.c bsp.h bsp_macros.h
  group Components/mrfi
    ../../../../../Components/mrfi/: mrfi.c mrfi.h mrfi_defs.h
  group Components/nwk
    ../../../../../Components/simpliciti/nwk/: nwk.c nwk_api.c nwk_app.h nwk_frame.c nwk_globals.c nwk_QMgmt.c
    ../../../../../Components/SimpliciTI/nwk/: nwk.h nwk_api.h nwk_frame.h nwk_globals.h nwk_QMgmt.h nwk_types.h
  group Components/nwk applications
    ../../../../../Components/simpliciti/nwk_applications/: nwk_freq.c nwk_freq.h nwk_ioctl.c nwk_ioctl.h nwk_join.c nwk_join.h nwk_link.c nwk_link.h nwk_mgmt.c nwk_mgmt.h nwk_ping.c nwk_ping.h nwk_pll.c nwk_security.c nwk_security.h
    ../../../../../Components/SimpliciTI/nwk_applications/: nwk_pll.h
  group peer applications/application/Access Point
    ../../../Applications/: main_AP_RE.c
  group peer applications/application/End Device
    ../../../Applications/: main_2EDOnePolls.c
  group peer applications/Configuration
    Configuration/: smpl_nwk_config.dat
  group peer applications/Configuration/Access Point
    Configuration/Access_Point/: smpl_config.dat
  group peer applications/Configuration/End Device
    Configuration/End_Device/: smpl_config.dat
  group peer applications/Configuration/Range Extender
    Configuration/Range_Extender/: smpl_config.dat
