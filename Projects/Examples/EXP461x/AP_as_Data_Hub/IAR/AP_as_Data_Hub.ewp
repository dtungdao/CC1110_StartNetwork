# IAR project AP_as_Data_Hub.ewp, settings and files
configuration CC1100-End Device (MSP430, debug)
  General.OGChipSelectMenu: MSP430FG4618 MSP430FG4618
  General.GStackSize2: 300
  General.GHeapSize2: 0
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: MRFI_CC1100
  ICC430.IExtraOptions: -f"Configuration\End_Device\smpl_config.dat"; -f"Configuration\smpl_nwk_config.dat"
  ICC430.newCCIncludePaths: ..\..\..\..\..\Components\bsp; ..\..\..\..\..\Components\bsp\drivers; ..\..\..\..\..\Components\bsp\boards\EXP461x; ..\..\..\..\..\Components\mrfi; ..\..\..\..\..\Components\SimpliciTI\nwk; ..\..\..\..\..\Components\SimpliciTI\nwk_applications
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430FG4618.xcl
  XLINK.XlinkStackSize: 1
configuration CC1100-Access Point (MSP430, debug)
  as the first configuration, except:
  ICC430.IExtraOptions: -f"Configuration\Access_Point\smpl_config.dat"; -f"Configuration\smpl_nwk_config.dat"
configuration CC1100-Channel Sniffer (MSP430, debug)
  as the first configuration, except:
  ICC430.CCDefines: MRFI_CC1100; NUM_CONNECTIONS=0
configuration CC1100-Range Extender (MSP430, debug)
  as the first configuration, except:
  ICC430.IExtraOptions: -f"Configuration\Range_Extender\smpl_config.dat"; -f"Configuration\smpl_nwk_config.dat"
configuration CC1101-End Device (MSP430, debug)
  as the first configuration, except:
  ICC430.CCDefines: MRFI_CC1101
configuration CC1101-Access Point (MSP430, debug)
  as the first configuration, except:
  ICC430.CCDefines: MRFI_CC1101
  ICC430.IExtraOptions: as above
configuration CC1101-Channel Sniffer (MSP430, debug)
  as the first configuration, except:
  ICC430.CCDefines: MRFI_CC1101; NUM_CONNECTIONS=0
configuration CC1101-Range Extender (MSP430, debug)
  as the first configuration, except:
  ICC430.CCDefines: MRFI_CC1101
  ICC430.IExtraOptions: as above
configuration CC1100E-End Device (MSP430, debug)
  as the first configuration, except:
  ICC430.CCDefines: MRFI_CC1100E_470; xMRFI_CC1100E_950
configuration CC1100E-Access Point (MSP430, debug)
  as the first configuration, except:
  ICC430.CCDefines: MRFI_CC1100E_470; xMRFI_CC1100E_950
  ICC430.IExtraOptions: as above
configuration CC1100E-Channel Sniffer (MSP430, debug)
  as the first configuration, except:
  ICC430.CCDefines: MRFI_CC1100E_470; xMRFI_CC1100E_950; NUM_CONNECTIONS=0
configuration CC1100E-Range Extender (MSP430, debug)
  as the first configuration, except:
  ICC430.CCDefines: MRFI_CC1100E_470; xMRFI_CC1100E_950
  ICC430.IExtraOptions: as above
configuration CC2500-End Device (MSP430, debug)
  as the first configuration, except:
  ICC430.CCDefines: MRFI_CC2500
configuration CC2500-Access Point (MSP430, debug)
  as the first configuration, except:
  ICC430.CCDefines: MRFI_CC2500
  ICC430.IExtraOptions: as above
configuration CC2500-Channel Sniffer (MSP430, debug)
  as the first configuration, except:
  ICC430.CCDefines: MRFI_CC2500; NUM_CONNECTIONS=0
configuration CC2500-Range Extender (MSP430, debug)
  as the first configuration, except:
  ICC430.CCDefines: MRFI_CC2500
  ICC430.IExtraOptions: as above
  group Components/bsp
    ../../../../../Components/bsp/: bsp.c bsp.h bsp_macros.h
  group Components/mrfi
    ../../../../../Components/mrfi/: mrfi.c mrfi.h mrfi_defs.h
  group Components/nwk
    ../../../../../Components/simpliciti/nwk/: nwk.c nwk_api.c nwk_app.h nwk_frame.c nwk_globals.c nwk_QMgmt.c
    ../../../../../Components/SimpliciTI/nwk/: nwk.h nwk_api.h nwk_frame.h nwk_globals.h nwk_QMgmt.h nwk_types.h
  group Components/nwk applications
    ../../../../../Components/simpliciti/nwk_applications/: nwk_freq.c nwk_freq.h nwk_ioctl.c nwk_ioctl.h nwk_join.c nwk_join.h nwk_link.c nwk_link.h nwk_mgmt.c nwk_mgmt.h nwk_ping.c nwk_pll.c nwk_security.c nwk_security.h
    ../../../../../Components/SimpliciTI/nwk_applications/: nwk_ping.h nwk_pll.h
  group peer applications/application/Access Point
    ../../../Applications/: main_AP_Async_Listen.c main_AP_Async_Listen_autoack.c
  group peer applications/application/Channel Sniffer
    ../../../Applications/: main_ED_Sniffer.c
  group peer applications/application/End Device
    ../../../Applications/: main_manyEDs.c main_manyEDs_autoack.c
  group peer applications/application/Range Extender
    ../../../Applications/: main_AP_RE.c
  group peer applications/Configuration
    Configuration/: smpl_nwk_config.dat
  group peer applications/Configuration/Access Point
    Configuration/Access_Point/: smpl_config.dat
  group peer applications/Configuration/End Device
    Configuration/End_Device/: smpl_config.dat
  group peer applications/Configuration/Range Extender
    Configuration/Range_Extender/: smpl_config.dat
