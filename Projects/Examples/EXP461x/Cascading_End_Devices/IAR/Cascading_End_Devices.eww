<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Cascading_End_Devices.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All Devices</name>
      <member>
        <project>Cascading_End_Devices</project>
        <configuration>CC1100-End Device</configuration>
      </member>
      <member>
        <project>Cascading_End_Devices</project>
        <configuration>CC1101-End Device</configuration>
      </member>
      <member>
        <project>Cascading_End_Devices</project>
        <configuration>CC1100E-End Device</configuration>
      </member>
      <member>
        <project>Cascading_End_Devices</project>
        <configuration>CC2500-End Device</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


