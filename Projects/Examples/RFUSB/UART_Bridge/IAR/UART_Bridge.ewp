# IAR project UART_Bridge.ewp, settings and files
configuration CC2511-LinkTo (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2511F32.i51
  ICC8051.CCDefines: MCU_H="ioCC2511.h"; MRFI_CC2511
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\..\..\..\..\Components\bsp; ..\..\..\..\..\Components\bsp\drivers; ..\..\..\..\..\Components\bsp\boards\RFUSB; ..\..\..\..\..\Components\mrfi; ..\..\..\..\..\Components\SimpliciTI\nwk; ..\..\..\..\..\Components\SimpliciTI\nwk_applications
  ICC8051.CCStdIncludePath: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 2
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnk51ew_cc1110.xcl
configuration CC2511-LinkListen (8051, debug)
  as the first configuration, except:
configuration CC1111-LinkTo (8051, debug)
  as the first configuration, except:
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC1111F32.i51
  ICC8051.CCDefines: MCU_H="ioCC1111.h"; MRFI_CC1111
configuration CC1111-LinkListen (8051, debug)
  as the first configuration, except:
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC1111F32.i51
  ICC8051.CCDefines: MCU_H="ioCC1111.h"; MRFI_CC1111
  group Components/bsp
    ../../../../../Components/bsp/: bsp.c bsp.h bsp_macros.h
  group Components/mrfi
    ../../../../../Components/mrfi/: mrfi.c mrfi.h mrfi_defs.h
  group Components/nwk
    ../../../../../Components/simpliciti/nwk/: nwk.c nwk_api.c nwk_app.h nwk_frame.c nwk_globals.c nwk_QMgmt.c
    ../../../../../Components/SimpliciTI/nwk/: nwk.h nwk_api.h nwk_frame.h nwk_globals.h nwk_QMgmt.h nwk_types.h
  group Components/nwk applications
    ../../../../../Components/simpliciti/nwk_applications/: nwk_freq.c nwk_freq.h nwk_ioctl.c nwk_ioctl.h nwk_join.c nwk_join.h nwk_link.c nwk_link.h nwk_mgmt.c nwk_mgmt.h nwk_ping.c nwk_ping.h nwk_pll.c nwk_security.c nwk_security.h
    ../../../../../Components/SimpliciTI/nwk_applications/: nwk_pll.h
  group peer applications
    ../../../../../Components/bsp/drivers/code/: uart.c uart_intfc.c
  group peer applications/application
    ../../../Applications/: main_UART_Bridge.c
  group peer applications/Configuration
    Configuration/: smpl_nwk_config.dat
  group peer applications/Configuration/LinkListen
    Configuration/LinkListen/: smpl_config.dat
  group peer applications/Configuration/LinkTo
    Configuration/LinkTo/: smpl_config.dat
