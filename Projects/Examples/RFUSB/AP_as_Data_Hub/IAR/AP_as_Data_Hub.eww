<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Ap_as_Data_Hub.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All Devices</name>
      <member>
        <project>Ap_as_Data_Hub</project>
        <configuration>CC1111-Access Point</configuration>
      </member>
      <member>
        <project>Ap_as_Data_Hub</project>
        <configuration>CC1111-Channel Sniffer</configuration>
      </member>
      <member>
        <project>Ap_as_Data_Hub</project>
        <configuration>CC1111-End Device</configuration>
      </member>
      <member>
        <project>Ap_as_Data_Hub</project>
        <configuration>CC1111-Range Extender</configuration>
      </member>
      <member>
        <project>Ap_as_Data_Hub</project>
        <configuration>CC2511-Access Point</configuration>
      </member>
      <member>
        <project>Ap_as_Data_Hub</project>
        <configuration>CC2511-Channel Sniffer</configuration>
      </member>
      <member>
        <project>Ap_as_Data_Hub</project>
        <configuration>CC2511-End Device</configuration>
      </member>
      <member>
        <project>Ap_as_Data_Hub</project>
        <configuration>CC2511-Range Extender</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>CC1111 Devices</name>
      <member>
        <project>Ap_as_Data_Hub</project>
        <configuration>CC1111-Access Point</configuration>
      </member>
      <member>
        <project>Ap_as_Data_Hub</project>
        <configuration>CC1111-Channel Sniffer</configuration>
      </member>
      <member>
        <project>Ap_as_Data_Hub</project>
        <configuration>CC1111-End Device</configuration>
      </member>
      <member>
        <project>Ap_as_Data_Hub</project>
        <configuration>CC1111-Range Extender</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>CC2511 Devices</name>
      <member>
        <project>Ap_as_Data_Hub</project>
        <configuration>CC2511-Access Point</configuration>
      </member>
      <member>
        <project>Ap_as_Data_Hub</project>
        <configuration>CC2511-Channel Sniffer</configuration>
      </member>
      <member>
        <project>Ap_as_Data_Hub</project>
        <configuration>CC2511-End Device</configuration>
      </member>
      <member>
        <project>Ap_as_Data_Hub</project>
        <configuration>CC2511-Range Extender</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


