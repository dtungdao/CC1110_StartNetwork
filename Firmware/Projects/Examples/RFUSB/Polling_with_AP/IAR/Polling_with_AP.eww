<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Polling_with_AP.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All Devices</name>
      <member>
        <project>Polling_with_AP</project>
        <configuration>CC1111-Sender</configuration>
      </member>
      <member>
        <project>Polling_with_AP</project>
        <configuration>CC1111-Receiver</configuration>
      </member>
      <member>
        <project>Polling_with_AP</project>
        <configuration>CC1111-Access Point</configuration>
      </member>
      <member>
        <project>Polling_with_AP</project>
        <configuration>CC1111-Range Extender</configuration>
      </member>
      <member>
        <project>Polling_with_AP</project>
        <configuration>CC2511-Sender</configuration>
      </member>
      <member>
        <project>Polling_with_AP</project>
        <configuration>CC2511-Receiver</configuration>
      </member>
      <member>
        <project>Polling_with_AP</project>
        <configuration>CC2511-Access Point</configuration>
      </member>
      <member>
        <project>Polling_with_AP</project>
        <configuration>CC2511-Range Extender</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>CC1111 Devices</name>
      <member>
        <project>Polling_with_AP</project>
        <configuration>CC1111-Sender</configuration>
      </member>
      <member>
        <project>Polling_with_AP</project>
        <configuration>CC1111-Receiver</configuration>
      </member>
      <member>
        <project>Polling_with_AP</project>
        <configuration>CC1111-Access Point</configuration>
      </member>
      <member>
        <project>Polling_with_AP</project>
        <configuration>CC1111-Range Extender</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>CC2511 Devices</name>
      <member>
        <project>Polling_with_AP</project>
        <configuration>CC2511-Sender</configuration>
      </member>
      <member>
        <project>Polling_with_AP</project>
        <configuration>CC2511-Receiver</configuration>
      </member>
      <member>
        <project>Polling_with_AP</project>
        <configuration>CC2511-Access Point</configuration>
      </member>
      <member>
        <project>Polling_with_AP</project>
        <configuration>CC2511-Range Extender</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


