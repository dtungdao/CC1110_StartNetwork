<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Polling_with_AP.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All Devices</name>
      <member>
        <project>Polling_with_AP</project>
        <configuration>CC1100-Sender</configuration>
      </member>
      <member>
        <project>Polling_with_AP</project>
        <configuration>CC1100-Receiver</configuration>
      </member>
      <member>
        <project>Polling_with_AP</project>
        <configuration>CC1100-Range Extender</configuration>
      </member>
      <member>
        <project>Polling_with_AP</project>
        <configuration>CC1100-Access Point</configuration>
      </member>
      <member>
        <project>Polling_with_AP</project>
        <configuration>CC1101-Sender</configuration>
      </member>
      <member>
        <project>Polling_with_AP</project>
        <configuration>CC1101-Receiver</configuration>
      </member>
      <member>
        <project>Polling_with_AP</project>
        <configuration>CC1101-Access Point</configuration>
      </member>
      <member>
        <project>Polling_with_AP</project>
        <configuration>CC1101-Range Extender</configuration>
      </member>
      <member>
        <project>Polling_with_AP</project>
        <configuration>CC1100E-Sender</configuration>
      </member>
      <member>
        <project>Polling_with_AP</project>
        <configuration>CC1100E-Receiver</configuration>
      </member>
      <member>
        <project>Polling_with_AP</project>
        <configuration>CC1100E-Access Point</configuration>
      </member>
      <member>
        <project>Polling_with_AP</project>
        <configuration>CC1100E-Range Extender</configuration>
      </member>
      <member>
        <project>Polling_with_AP</project>
        <configuration>CC2500-Sender</configuration>
      </member>
      <member>
        <project>Polling_with_AP</project>
        <configuration>CC2500-Receiver</configuration>
      </member>
      <member>
        <project>Polling_with_AP</project>
        <configuration>CC2500-Access Point</configuration>
      </member>
      <member>
        <project>Polling_with_AP</project>
        <configuration>CC2500-Range Extender</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>CC1100 Devices</name>
      <member>
        <project>Polling_with_AP</project>
        <configuration>CC1100-Sender</configuration>
      </member>
      <member>
        <project>Polling_with_AP</project>
        <configuration>CC1100-Receiver</configuration>
      </member>
      <member>
        <project>Polling_with_AP</project>
        <configuration>CC1100-Access Point</configuration>
      </member>
      <member>
        <project>Polling_with_AP</project>
        <configuration>CC1100-Range Extender</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>CC1101 Devices</name>
      <member>
        <project>Polling_with_AP</project>
        <configuration>CC1101-Sender</configuration>
      </member>
      <member>
        <project>Polling_with_AP</project>
        <configuration>CC1101-Receiver</configuration>
      </member>
      <member>
        <project>Polling_with_AP</project>
        <configuration>CC1101-Access Point</configuration>
      </member>
      <member>
        <project>Polling_with_AP</project>
        <configuration>CC1101-Range Extender</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>CC1100E Devices</name>
      <member>
        <project>Polling_with_AP</project>
        <configuration>CC1100E-Sender</configuration>
      </member>
      <member>
        <project>Polling_with_AP</project>
        <configuration>CC1100E-Receiver</configuration>
      </member>
      <member>
        <project>Polling_with_AP</project>
        <configuration>CC1100E-Access Point</configuration>
      </member>
      <member>
        <project>Polling_with_AP</project>
        <configuration>CC1100E-Range Extender</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>CC2500 Devices</name>
      <member>
        <project>Polling_with_AP</project>
        <configuration>CC2500-Sender</configuration>
      </member>
      <member>
        <project>Polling_with_AP</project>
        <configuration>CC2500-Receiver</configuration>
      </member>
      <member>
        <project>Polling_with_AP</project>
        <configuration>CC2500-Access Point</configuration>
      </member>
      <member>
        <project>Polling_with_AP</project>
        <configuration>CC2500-Range Extender</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
