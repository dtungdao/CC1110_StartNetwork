<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Polling_with_AP.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All Devices</name>
      <member>
        <project>Polling_with_AP</project>
        <configuration>CC1110-Sender</configuration>
      </member>
      <member>
        <project>Polling_with_AP</project>
        <configuration>CC1110-Receiver</configuration>
      </member>
      <member>
        <project>Polling_with_AP</project>
        <configuration>CC1110-Access Point</configuration>
      </member>
      <member>
        <project>Polling_with_AP</project>
        <configuration>CC1110-Range Extender</configuration>
      </member>
      <member>
        <project>Polling_with_AP</project>
        <configuration>CC2430-Sender</configuration>
      </member>
      <member>
        <project>Polling_with_AP</project>
        <configuration>CC2430-Receiver</configuration>
      </member>
      <member>
        <project>Polling_with_AP</project>
        <configuration>CC2430-Access Point</configuration>
      </member>
      <member>
        <project>Polling_with_AP</project>
        <configuration>CC2430-Range Extender</configuration>
      </member>
      <member>
        <project>Polling_with_AP</project>
        <configuration>CC2510-Sender</configuration>
      </member>
      <member>
        <project>Polling_with_AP</project>
        <configuration>CC2510-Receiver</configuration>
      </member>
      <member>
        <project>Polling_with_AP</project>
        <configuration>CC2510-Access Point</configuration>
      </member>
      <member>
        <project>Polling_with_AP</project>
        <configuration>CC2510-Range Extender</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>CC1110 Devices</name>
      <member>
        <project>Polling_with_AP</project>
        <configuration>CC1110-Sender</configuration>
      </member>
      <member>
        <project>Polling_with_AP</project>
        <configuration>CC1110-Receiver</configuration>
      </member>
      <member>
        <project>Polling_with_AP</project>
        <configuration>CC1110-Access Point</configuration>
      </member>
      <member>
        <project>Polling_with_AP</project>
        <configuration>CC1110-Range Extender</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>CC2430 Devices</name>
      <member>
        <project>Polling_with_AP</project>
        <configuration>CC2430-Sender</configuration>
      </member>
      <member>
        <project>Polling_with_AP</project>
        <configuration>CC2430-Receiver</configuration>
      </member>
      <member>
        <project>Polling_with_AP</project>
        <configuration>CC2430-Access Point</configuration>
      </member>
      <member>
        <project>Polling_with_AP</project>
        <configuration>CC2430-Range Extender</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>CC2510 Devices</name>
      <member>
        <project>Polling_with_AP</project>
        <configuration>CC2510-Sender</configuration>
      </member>
      <member>
        <project>Polling_with_AP</project>
        <configuration>CC2510-Receiver</configuration>
      </member>
      <member>
        <project>Polling_with_AP</project>
        <configuration>CC2510-Access Point</configuration>
      </member>
      <member>
        <project>Polling_with_AP</project>
        <configuration>CC2510-Range Extender</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


