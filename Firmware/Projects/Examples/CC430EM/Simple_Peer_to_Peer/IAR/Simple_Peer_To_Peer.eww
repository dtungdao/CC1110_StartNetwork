<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Simple_Peer_To_Peer.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All Devices</name>
      <member>
        <project>Simple_Peer_To_Peer</project>
        <configuration>CC430F5137-LinkListen</configuration>
      </member>
      <member>
        <project>Simple_Peer_To_Peer</project>
        <configuration>CC430F5137-LinkTo</configuration>
      </member>
      <member>
        <project>Simple_Peer_To_Peer</project>
        <configuration>CC430F6137-LinkListen</configuration>
      </member>
      <member>
        <project>Simple_Peer_To_Peer</project>
        <configuration>CC430F6137-LinkTo</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


