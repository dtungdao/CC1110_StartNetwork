<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Polling_with_AP.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All Devices</name>
      <member>
        <project>Polling_with_AP</project>
        <configuration>CC2520-Sender</configuration>
      </member>
      <member>
        <project>Polling_with_AP</project>
        <configuration>CC2520-Receiver</configuration>
      </member>
      <member>
        <project>Polling_with_AP</project>
        <configuration>CC2520-Access Point</configuration>
      </member>
      <member>
        <project>Polling_with_AP</project>
        <configuration>CC2520-Range Extender</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


