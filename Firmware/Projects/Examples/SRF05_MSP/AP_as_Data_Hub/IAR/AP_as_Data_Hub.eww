<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Ap_as_Data_Hub.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All Devices</name>
      <member>
        <project>Ap_as_Data_Hub</project>
        <configuration>CC2520-End Device</configuration>
      </member>
      <member>
        <project>Ap_as_Data_Hub</project>
        <configuration>CC2520-Access Point</configuration>
      </member>
      <member>
        <project>Ap_as_Data_Hub</project>
        <configuration>CC2520-Channel Sniffer</configuration>
      </member>
      <member>
        <project>Ap_as_Data_Hub</project>
        <configuration>CC2520-Range Extender</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


